EXTRA_OECONF_remove = "ac_cv_header_bluetooth_bluetooth_h=no ac_cv_header_bluetooth_h=no"
