PACKAGECONFIG_append = " modemmanager bluez5"
