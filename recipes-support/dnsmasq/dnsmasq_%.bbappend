PACKAGECONFIG_append = " dbus"
