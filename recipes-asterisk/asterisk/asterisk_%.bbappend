PACKAGECONFIG_append = " dahdi tonezone gsm"
